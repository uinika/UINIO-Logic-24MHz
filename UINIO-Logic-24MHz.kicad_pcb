# Repository uinika/UINIO-Logic-24MHz

File README.md:

# UINIO-Logic-24MHz 逻辑分析仪

[**UINIO-Logic-24MHz**](https://gitee.com/uinika/UINIO-Logic-24MHz) 是一款基于**英飞凌**（已收购**赛普拉斯 Cypress**）的 [**CY7C68013A**](https://www.infineon.com/cms/en/product/universal-serial-bus-usb-power-delivery-controller/peripheral-controllers/ez-usb-fx2lp/cy7c68013a-56ltxit/) 型 `USB2.0` 控制器，以及 [**Sigork**](https://sigrok.org/) 开源固件方案的逻辑分析仪电路设计。拥有 `24MHz` 采样频率，以及 **8** 个采样通道。

## 设计概要

1. 采用 **USB Type-C** 接口，以及 `10 Pin` 的牛角插座；
2. **CY7C68013A** 型 USB 控制器芯片采用了体积较小的 `QFN56` 封装；
3. **AT24C64** 微芯 EEPROM 存储器芯片同样采用体积小巧的 `TSSOP8` 封装；
4. 板载 `24MHz` 无源贴片晶振，阻容贴片元件全部采用 `0402` 的小规格封装；
5. 增加具有**三态输出**功能的 **74HC245** 八路信号收发器，提升信号采集的稳定性；
6. 低压差线性稳压器可以灵活选用 `ME6211C33M5G` 或者 `A6303AE5R-33A` 等 `SOT23-5` 封装的 **LDO** 芯片；
7. **USB Type-C** 接口位置新增一组 TVS 瞬态电压抑制二极管；

## 注意事项

- LED 指示灯 `D2` 连接至 **CY7C68013A** 的 `PA0` 引脚，而 `D3` 则被连接至 `PA1` 引脚；
- 需要结合 **Sigork** 的开源固件 [sigrok-firmware-fx2lafw](https://github.com/wuxx/sigrok-firmware-fx2lafw)，并且搭配 [PulseView](https://sigrok.org/wiki/Downloads) 上位机协同使用；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 **UINIO-Logic-24MHz** 开源项目提供了如下一系列技术参考资料：

- [《UINIO-Logic-24MHz 核心板原理图》](http://uinio.com/my/works/UINIO-Logic-24MHz/UINIO-Logic-24MHz-Schematic.pdf)
- [《交互式 BOM 物料清单与 PCB 版图在线预览》](http://uinio.com/archives/BOM/UINIO-Logic-24MHz.html)
- [《快速上手 UINIO-Logic-24MHz 逻辑分析仪》](http://uinio.com/Project/UINIO-Logic-24MHz/)

## KiCad design UINIO-Logic-24MHz.kicad_pcb

Parts:
C1, C2: 1uF; C_0603_1608Metric
C3, C4, C5, C6, C7, C11, C12: 0.1uF; C_0402_1005Metric
C8, C9: 12pF; C_0402_1005Metric
C10: 1uF; C_0402_1005Metric
D1: LED Red; LED_0603_1608Metric
D2: LED Yellow; LED_0603_1608Metric
D3: LED Green; LED_0603_1608Metric
D4: 1N4007; Nexperia_CFP3_SOD-123W
D5, D6: LESD5D5.0CT1G; D_SOD-523
F1: 60V 1A; Fuse_1206_3216Metric
J1: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 100R; R_0402_1005Metric
R9, R10, R11, R12, R13, R14, R15, R16, R23: 100K; R_0402_1005Metric
R17: 1K; R_0402_1005Metric
R18, R19, R20: 10K; R_0402_1005Metric
R21, R22: 2.2K; R_0402_1005Metric
R24, R25: 5.1K; R_0603_1608Metric
U1: AT24CS64-XHM; TSSOP-8_4.4x3mm_P0.65mm
U2: 74HC245C; TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL
U3: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U4: CY7C68013A-56LTX; QFN-56-1EP_8x8mm_P0.5mm_EP4.5x5.2mm_ThermalVias_TopTented
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y1: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, C11.1, C12.1, D4.1 (K), F1.2, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.2, R20.2, R21.1, R22.1, R23.2, U1.8 (VCC), U2.20 (VCC), U4.3 (AVCC), U4.7 (AVCC), U4.11 (VCC), U4.17 (VCC), U4.27 (VCC), U4.32 (VCC), U4.43 (VCC), U4.55 (VCC)
+5V: C1.2, U3.1 (Vin), U3.3 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/I2C_SCL: R22.2, U1.6 (SCL), U4.15 (SCL)
/I2C_SDA: R21.2, U1.5 (SDA), U4.16 (SDA)
/INPUT1: R8.1, R9.2, U2.18 (B1)
/INPUT2: R7.1, R10.2, U2.17 (B2)
/INPUT3: R6.1, R11.2, U2.16 (B3)
/INPUT4: R5.1, R12.2, U2.15 (B4)
/INPUT5: R4.1, R13.2, U2.14 (B5)
/INPUT6: R3.1, R14.2, U2.13 (B6)
/INPUT7: R2.1, R15.2, U2.12 (B7)
/INPUT8: R1.1, R16.2, U2.11 (B8)
/PB0: U2.9 (A8), U4.18 (PB0/FD0)
/PB1: U2.8 (A7), U4.19 (PB1/FD1)
/PB2: U2.7 (A6), U4.20 (PB2/FD2)
/PB3: U2.6 (A5), U4.21 (PB3/FD3)
/PB4: U2.5 (A4), U4.22 (PB4/FD4)
/PB5: U2.4 (A3), U4.23 (PB5/FD5)
/PB6: U2.3 (A2), U4.24 (PB6/FD6)
/PB7: U2.2 (A1), U4.25 (PB7/FD7)
/USB_Data+: D6.2 (A2), U4.8 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
/USB_Data-: D5.2 (A2), U4.9 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.2, C12.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.2 (A), D5.1 (A1), D6.1 (A1), J1.1, J1.10, R24.2, R25.2, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.4 (GND), U1.7 (WP), U2.1 (DIR), U2.10 (GND), U2.19 (/OE), U3.2 (Vss), U4.6 (AGND), U4.10 (AGND), U4.12 (GND), U4.14 (RESERVED), U4.26 (GND), U4.28 (GND), U4.41 (GND), U4.53 (GND), U4.56 (GND), U4.57 (EP), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND), Y1.2, Y1.4
unnamed: D1.2 (A), R17.1
unnamed: D2.2 (A), R18.1
unnamed: D3.2 (A), R19.1
unnamed: J1.2, R8.2
unnamed: J1.3, R7.2
unnamed: J1.4, R6.2
unnamed: J1.5, R5.2
unnamed: J1.6, R4.2
unnamed: J1.7, R3.2
unnamed: J1.8, R2.2
unnamed: J1.9, R1.2
unnamed: C2.2, F1.1, U3.5 (Vout)
unnamed: R18.2, U4.33 (PA0/~INT0)
unnamed: R19.2, U4.34 (PA1/~INT1)
unnamed: R20.1, U4.44 (WAKEUP)
unnamed: C9.2, U4.5 (XTALIN), Y1.1
unnamed: C8.2, U4.4 (XTALOUT), Y1.3
unnamed: C10.2, R23.1, U4.42 (~RESET)
unnamed: R24.1, USB1.A5 (CC1)
unnamed: R25.1, USB1.B5 (CC2)

Notes on the sheet:
CY7C68013A USB2.0 控制器
LDO 线性稳压电路
信 号 收 发 器
上拉电阻
USB Type-C 接口电路
EEPROM 存储器

Board: 2 copper layers, 52.0 x 25.4 mm, 55 parts (0 on the bottom side), 43 nets.

Other parts of the board:
HOLE1, HOLE2, HOLE3, HOLE4: Hole-2mm

## Commit log

2022-12-30 Release UINIO-Logic-24MHz version 1.0.0.
2023-01-28 Preparing release version 2.0.0.
2023-01-29 Release UINIO-Logic-24MHz version 2.0.0.
2023-02-03 Prepare UINIO-Logic-24MHz version 3.0.0.
2023-02-04 Release UINIO-Logic-24MHz version 3.0.0.
2023-02-19 Commit 3D Shell.
2023-06-29 Prepare version 3.1.0.
2023-06-29 Release UINIO-Logic-24MHz version 3.1.0.
2023-07-11 Update README.md.
2024-01-11 Release UINIO-Logic-24MHz version 3.1.1.
2024-04-19 Release UINIO-Logic-24MHz version 3.2.0.
2024-10-23 Reorganize component.
2024-10-29 Release UINIO-Logic-24MHz version 5.0.0.
2024-10-29 Release UINIO-Logic-24MHz version 5.0.0. :x lease :x update
